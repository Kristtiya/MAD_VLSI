v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 0 120 -0 180 { lab=Vb}
N -0 60 0 120 { lab=Vb}
N 0 -0 -0 60 { lab=Vb}
N -0 -0 30 -0 { lab=Vb}
N 30 -0 30 30 { lab=Vb}
N 30 30 30 90 { lab=Vb}
N 30 90 30 150 { lab=Vb}
N 30 150 30 210 { lab=Vb}
N -30 150 -30 210 { lab=VP}
N -30 90 -30 150 { lab=VP}
N -30 30 -30 90 { lab=VP}
N -30 -80 -30 30 { lab=VP}
N 90 120 90 180 { lab=Vb}
N 90 60 90 120 { lab=Vb}
N 90 0 90 60 { lab=Vb}
N 120 30 120 90 { lab=VP}
N 120 90 120 150 { lab=VP}
N 120 150 120 210 { lab=VP}
N 60 150 60 210 { lab=#net1}
N 60 90 60 150 { lab=#net1}
N 60 30 60 90 { lab=#net1}
N 120 -80 120 30 { lab=VP}
N 90 180 90 220 { lab=Vb}
N 60 210 60 225 { lab=#net1}
N 130 210 150 210 { lab=VP}
N 130 -80 130 210 { lab=VP}
N 180 180 180 220 { lab=Vb}
N 210 210 210 230 { lab=Vbn}
N 90 230 210 230 { lab=Vbn}
N 90 230 90 240 { lab=Vbn}
N 210 270 210 330 { lab=Vcp}
N 210 330 210 390 { lab=Vcp}
N 210 390 210 450 { lab=Vcp}
N 150 390 150 450 { lab=VN}
N 150 330 150 390 { lab=VN}
N 150 270 150 330 { lab=VN}
N 180 360 180 420 { lab=Vbn}
N 180 300 180 360 { lab=Vbn}
N 180 240 180 300 { lab=Vbn}
N 90 230 90 300 { lab=Vbn}
N 120 240 120 270 { lab=Vbn}
N 90 240 120 240 { lab=Vbn}
N 55 270 60 270 { lab=VN}
N 150 450 150 540 { lab=VN}
N 120 330 140 330 { lab=#net2}
N 140 150 140 330 { lab=#net2}
N 140 150 150 150 { lab=#net2}
N 210 90 210 150 { lab=#net3}
N 145 90 150 90 { lab=VP}
N 180 60 180 120 { lab=#net2}
N 135 90 145 90 { lab=VP}
N 135 -80 135 90 { lab=VP}
N 140 120 180 120 { lab=#net2}
N 140 120 140 150 { lab=#net2}
N 210 270 220 270 { lab=Vcp}
N 220 30 220 270 { lab=Vcp}
N 210 30 220 30 { lab=Vcp}
N 180 0 220 -0 { lab=Vcp}
N 220 -0 220 30 { lab=Vcp}
N 220 -0 295 -0 { lab=Vcp}
N 180 240 300 240 { lab=Vbn}
N -115 -80 -115 210 { lab=VP}
N -85 -40 -0 -40 { lab=Vb}
N -85 -40 -85 180 { lab=Vb}
N 50 330 60 330 { lab=VN}
N 50 330 50 540 { lab=VN}
N 40 270 55 270 { lab=VN}
N 40 270 40 540 { lab=VN}
N 30 225 60 225 { lab=#net1}
N 30 225 30 270 { lab=#net1}
N -0 240 30 240 { lab=#net1}
N -30 270 -30 330 { lab=#net4}
N 30 330 35 330 { lab=VN}
N 35 330 35 540 { lab=VN}
N -0 345 0 360 { lab=Vcn}
N -30 345 0 345 { lab=Vcn}
N -30 345 -30 390 { lab=Vcn}
N -50 345 -30 345 { lab=Vcn}
N -50 210 -50 345 { lab=Vcn}
N -55 210 -50 210 { lab=Vcn}
N 30 335 30 390 { lab=#net4}
N -40 335 30 335 { lab=#net4}
N -40 300 -40 335 { lab=#net4}
N -40 300 -30 300 { lab=#net4}
N 50 540 150 540 { lab=VN}
N 40 540 50 540 { lab=VN}
N 35 540 40 540 { lab=VN}
N -110 540 35 540 { lab=VN}
N -170 540 -105 540 { lab=VN}
N -0 345 300 345 { lab=Vcn}
N -0 240 0 300 { lab=#net1}
N 180 230 180 240 { lab=Vbn}
N -180 -80 150 -80 { lab=VP}
N 150 30 150 55 { lab=#net3}
N 150 55 215 55 { lab=#net3}
N 215 55 215 125 { lab=#net3}
N 210 125 215 125 { lab=#net3}
N -50 -0 -50 180 { lab=Vb}
N -50 -0 -0 -0 { lab=Vb}
N 90 -0 125 0 { lab=Vb}
N 125 0 125 220 { lab=Vb}
N 125 220 180 220 { lab=Vb}
N 45 220 90 220 { lab=Vb}
N 45 -40 45 220 { lab=Vb}
N 0 -40 45 -40 { lab=Vb}
N 180 180 270 180 { lab=Vbp}
N -50 180 -50 200 { lab=Vb}
N -85 200 -50 200 { lab=Vb}
N -85 180 -85 200 { lab=Vb}
C {devices/iopin.sym} -180 -80 2 0 {name=p2 lab=VP}
C {devices/iopin.sym} -170 540 2 0 {name=p3 lab=VN}
C {devices/opin.sym} 300 345 0 0 {name=p5 lab=Vcn}
C {devices/opin.sym} 295 0 0 0 {name=p6 lab=Vcp}
C {devices/opin.sym} 300 240 0 0 {name=p7 lab=Vbn}
C {devices/ipin.sym} 30 0 2 0 {name=p1 lab=Vb}
C {devices/opin.sym} 270 180 0 0 {name=p4 lab=Vbp}
C {madvlsi/pmos3.sym} 0 30 3 1 {name=M1
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 90 3 1 {name=M2
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 150 3 1 {name=M3
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 0 210 3 1 {name=M4
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 90 30 1 0 {name=M5
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 90 90 1 0 {name=M6
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 90 150 1 0 {name=M7
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 90 210 1 0 {name=M8
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 180 210 3 1 {name=M9
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 180 150 1 0 {name=M10
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 180 90 3 1 {name=M11
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 180 30 1 0 {name=M12
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 90 270 1 0 {name=M13
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 270 1 0 {name=M14
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 330 1 0 {name=M15
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 390 1 0 {name=M16
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 180 450 1 0 {name=M18
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 90 330 1 0 {name=M19
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -85 210 3 1 {name=M21
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 270 1 0 {name=M22
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 330 3 1 {name=M23
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 0 390 3 1 {name=M24
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
