v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 50 -35 50 0 { lab=VP}
N 435 130 435 155 { lab=VP}
N 110 130 115 130 { lab=VP}
N 135 360 135 370 { lab=VN}
N 435 -0 440 -0 { lab=Vbn}
N -75 65 35 65 { lab=Vb}
N -50 100 -5 100 { lab=VP}
N -50 130 -35 130 { lab=VP}
N -50 100 -50 130 { lab=VP}
N -5 260 -5 270 { lab=VN}
N -40 270 -5 270 { lab=VN}
N -50 270 -40 270 { lab=VN}
N -50 230 -50 270 { lab=VN}
N -50 230 -35 230 { lab=VN}
N 490 330 520 330 { lab=VN}
N 520 330 520 360 { lab=VN}
N -80 -100 -50 -100 { lab=VP}
N -65 460 365 460 { lab=VN}
N 520 360 520 460 { lab=VN}
N 565 30 565 100 { lab=#net1}
N 205 230 205 460 { lab=VN}
N 80 30 165 30 { lab=#net2}
N 165 30 245 30 { lab=#net2}
N 245 30 325 30 { lab=#net2}
N 325 30 355 30 { lab=#net2}
N 245 100 325 100 { lab=#net2}
N 325 100 405 100 { lab=#net2}
N 355 30 405 30 { lab=#net2}
N 80 30 80 100 { lab=#net2}
N 365 -100 365 -10 { lab=VP}
N 275 -0 295 -0 { lab=#net2}
N 110 0 135 -0 { lab=#net2}
N 125 -10 125 -0 { lab=#net2}
N 125 -10 285 -10 { lab=#net2}
N 285 -10 285 0 { lab=#net2}
N 195 130 215 130 { lab=Vcn}
N 355 130 375 130 { lab=Vcn}
N 50 -35 195 -35 { lab=VP}
N 195 -35 215 -35 { lab=VP}
N 215 -35 355 -35 { lab=VP}
N 205 130 205 140 { lab=Vcn}
N 205 140 365 140 { lab=Vcn}
N 365 130 365 140 { lab=Vcn}
N 275 130 295 130 { lab=VP}
N 285 130 285 155 { lab=VP}
N 285 155 435 155 { lab=VP}
N 135 155 285 155 { lab=VP}
N 135 130 135 155 { lab=VP}
N 195 -0 215 -0 { lab=VP}
N 25 130 50 130 { lab=#net3}
N 35 130 35 230 { lab=#net3}
N 25 230 35 230 { lab=#net3}
N 35 230 50 230 { lab=#net3}
N 80 260 165 260 { lab=#net3}
N 35 260 80 260 { lab=#net3}
N 35 230 35 260 { lab=#net3}
N 55 330 55 360 { lab=VN}
N 195 230 205 230 { lab=VN}
N 110 230 135 230 { lab=#net4}
N 125 220 125 230 { lab=#net4}
N 250 325 325 325 { lab=Vbn}
N 195 360 220 360 { lab=Vcp}
N 365 360 365 365 { lab=Vcp}
N 210 365 365 365 { lab=Vcp}
N 210 360 210 365 { lab=Vcp}
N 135 370 135 380 { lab=VN}
N 135 380 280 380 { lab=VN}
N 280 380 435 380 { lab=VN}
N 435 360 435 380 { lab=VN}
N 280 360 295 360 { lab=VN}
N 295 360 295 380 { lab=VN}
N 200 -35 200 0 { lab=VP}
N 135 380 135 460 { lab=VN}
N 115 360 135 360 { lab=VN}
N 435 360 460 360 { lab=VN}
N 455 215 465 215 { lab=#net1}
N 595 0 595 130 { lab=#net5}
N 430 325 605 325 { lab=Vbn}
N 35 65 610 65 { lab=Vb}
N 115 -100 115 130 { lab=VP}
N 285 -0 285 30 { lab=#net2}
N 535 90 565 90 { lab=#net1}
N 535 90 535 130 { lab=#net1}
N 365 365 530 365 { lab=Vcp}
N 565 260 570 260 { lab=Vcp}
N 570 260 585 260 { lab=Vcp}
N 355 360 375 360 { lab=Vcp}
N 120 130 135 130 { lab=VP}
N 165 100 245 100 { lab=#net2}
N 610 65 640 65 { lab=Vb}
N 605 325 715 325 { lab=Vbn}
N 715 250 715 325 { lab=Vbn}
N 715 250 755 250 { lab=Vbn}
N 55 330 85 330 { lab=VN}
N 55 365 55 460 { lab=VN}
N 115 130 120 130 { lab=VP}
N 355 -35 355 -0 { lab=VP}
N 355 -0 375 0 { lab=VP}
N 365 -10 365 0 { lab=VP}
N -50 -100 460 -100 { lab=VP}
N 55 360 55 365 { lab=VN}
N 640 65 725 65 { lab=Vb}
N 645 0 725 -0 { lab=Vcp}
N 495 100 495 130 { lab=VP}
N 465 100 495 100 { lab=VP}
N 500 -0 500 25 { lab=VP}
N 500 25 500 30 { lab=VP}
N 470 30 500 30 { lab=VP}
N 500 -100 500 -0 { lab=VP}
N 595 230 600 230 { lab=Vcp}
N 600 230 600 260 { lab=Vcp}
N 595 130 595 220 { lab=#net5}
N 465 215 535 215 { lab=#net1}
N 535 130 535 215 { lab=#net1}
N 460 -100 500 -100 { lab=VP}
N -50 70 -50 100 { lab=VP}
N -50 45 495 45 { lab=VP}
N -50 45 -50 70 { lab=VP}
N 500 30 500 45 { lab=VP}
N 495 45 500 45 { lab=VP}
N 495 100 500 100 { lab=VP}
N 365 460 520 460 { lab=VN}
N 520 295 520 330 { lab=VN}
N -50 295 520 295 { lab=VN}
N 440 -0 440 185 { lab=Vbn}
N 280 185 440 185 { lab=Vbn}
N 280 185 280 230 { lab=Vbn}
N 205 230 220 230 { lab=VN}
N 250 260 280 260 { lab=Vbn}
N 280 230 280 260 { lab=Vbn}
N 250 260 250 325 { lab=Vbn}
N 325 260 350 260 { lab=Vcn}
N 350 260 355 260 { lab=Vcn}
N 355 230 355 260 { lab=Vcn}
N 295 215 295 230 { lab=#net4}
N 125 215 295 215 { lab=#net4}
N 125 215 125 220 { lab=#net4}
N 325 260 325 275 { lab=Vcn}
N 325 275 755 275 { lab=Vcn}
N 585 260 630 260 { lab=Vcp}
N 630 -0 630 260 { lab=Vcp}
N 630 -0 645 -0 { lab=Vcp}
N 435 215 455 215 { lab=#net1}
N 435 215 435 230 { lab=#net1}
N 405 260 405 330 { lab=Vbn}
N 355 140 355 230 { lab=Vcn}
N -50 270 -50 295 { lab=VN}
N 285 275 315 275 { lab=VN}
N 315 275 315 305 { lab=VN}
N 280 230 285 230 { lab=Vbn}
N 285 230 285 265 { lab=Vbn}
N 260 265 285 265 { lab=Vbn}
N 255 265 260 265 { lab=Vbn}
N 255 265 255 305 { lab=Vbn}
N 535 -100 535 0 { lab=VP}
N 500 -100 535 -100 { lab=VP}
N 500 100 515 100 { lab=VP}
N 515 -100 515 100 { lab=VP}
N -35 -100 -35 0 { lab=VP}
N -35 30 -5 30 { lab=VP}
N -35 0 -35 30 { lab=VP}
N 80 100 165 100 { lab=#net2}
N 25 -0 50 -0 { lab=VP}
N 200 -100 200 -35 { lab=VP}
N 600 260 600 365 {}
N 530 365 600 365 {}
N 535 225 535 230 {}
N 535 225 595 225 {}
N 595 220 595 225 {}
N 165 325 165 330 {}
N 165 325 250 325 {}
N 250 325 250 330 {}
N 325 325 325 330 {}
N 325 325 405 325 {}
N 405 325 430 325 {}
N 285 30 285 65 {}
C {madvlsi/pmos3.sym} 80 0 3 0 {name=M1
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 325 230 1 1 {name=M2
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 165 0 1 1 {name=M3
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 245 0 3 0 {name=M4
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 325 0 1 1 {name=M5
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 165 130 3 1 {name=M6
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 245 130 1 0 {name=M7
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 325 130 3 1 {name=M8
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 405 130 1 0 {name=M9
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 80 130 1 0 {name=M10
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 80 230 3 0 {name=M11
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 165 230 3 0 {name=M12
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 230 1 1 {name=M13
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 405 230 1 1 {name=M14
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 405 0 3 0 {name=M15
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 325 360 1 0 {name=M16
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 405 360 3 1 {name=M17
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 360 3 1 {name=M18
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 165 360 1 0 {name=M19
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 565 0 3 0 {name=M20
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 565 130 1 0 {name=M21
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 565 230 3 0 {name=M22
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -80 -100 2 0 {name=p2 lab=VP}
C {devices/iopin.sym} -65 460 2 0 {name=p3 lab=VN}
C {devices/opin.sym} 755 275 0 0 {name=p5 lab=Vcn}
C {devices/opin.sym} 725 0 0 0 {name=p6 lab=Vcp}
C {devices/opin.sym} 755 250 0 0 {name=p7 lab=Vbn}
C {devices/ipin.sym} -75 65 0 0 {name=p1 lab=Vb}
C {madvlsi/pmos3.sym} 465 130 1 0 {name=M23
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 470 0 3 0 {name=M25
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} 375 230 3 0 {name=p4 lab=VN}
C {madvlsi/nmos3.sym} 285 305 3 1 {name=M30
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} 315 305 0 0 {name=p8 lab=VN}
C {madvlsi/nmos3.sym} 85 360 1 0 {name=M26
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 490 360 3 1 {name=M28
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} -5 230 1 1 {name=M24
L=0.5
W=12
body=VN
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -5 130 3 1 {name=M27
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} -5 0 3 0 {name=M29
L=0.5
W=12
body=VP
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
