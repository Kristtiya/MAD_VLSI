v {xschem version=2.9.9 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 295 -35 295 0 { lab=VP}
N 50 -35 50 0 { lab=VP}
N 135 -35 135 0 { lab=VP}
N 215 -35 215 -0 { lab=VP}
N 195 90 195 115 { lab=Vcn}
N 195 115 280 115 { lab=Vcn}
N 275 90 275 115 { lab=Vcn}
N 280 115 360 115 { lab=Vcn}
N 355 90 355 115 { lab=Vcn}
N 135 90 135 130 { lab=VP}
N 215 90 215 130 { lab=VP}
N 295 90 295 130 { lab=VP}
N 110 190 135 190 { lab=#net1}
N 80 220 80 235 { lab=#net2}
N 80 235 165 235 { lab=#net2}
N 165 220 165 235 { lab=#net2}
N 195 190 205 190 { lab=VN}
N 50 -35 295 -35 { lab=VP}
N 135 130 295 130 { lab=VP}
N 295 130 375 130 { lab=VP}
N 360 115 435 115 { lab=Vcn}
N 435 90 435 115 { lab=Vcn}
N 50 90 50 190 { lab=#net2}
N 110 90 115 90 { lab=VP}
N 115 70 115 90 { lab=VP}
N 250 220 250 235 { lab=Vcn}
N 250 235 280 235 { lab=Vcn}
N 280 190 280 235 { lab=Vcn}
N 220 175 220 190 { lab=#net1}
N 120 175 220 175 { lab=#net1}
N 120 175 120 190 { lab=#net1}
N 280 115 280 190 { lab=Vcn}
N 125 90 135 90 { lab=VP}
N 125 70 125 90 { lab=VP}
N 370 -0 375 -0 { lab=VP}
N 370 -35 370 -0 { lab=VP}
N 435 190 440 190 { lab=Vbn}
N 440 -0 440 190 { lab=Vbn}
N 405 220 440 220 { lab=Vbn}
N 440 190 440 220 { lab=Vbn}
N 365 190 375 190 { lab=VN}
N 365 190 365 200 { lab=VN}
N 325 220 405 220 { lab=Vbn}
N 295 175 295 190 { lab=#net3}
N 295 175 450 175 { lab=#net3}
N 165 250 165 255 { lab=Vbn}
N 165 250 250 250 { lab=Vbn}
N 250 250 250 255 { lab=Vbn}
N 250 250 325 250 { lab=Vbn}
N 325 250 325 255 { lab=Vbn}
N 325 250 405 250 { lab=Vbn}
N 405 250 405 255 { lab=Vbn}
N 325 220 325 255 { lab=Vbn}
N 195 285 195 300 { lab=#net4}
N 195 300 280 300 { lab=#net4}
N 280 285 280 300 { lab=#net4}
N 280 300 355 300 { lab=#net4}
N 355 285 355 300 { lab=#net4}
N 355 300 435 300 { lab=#net4}
N 435 285 435 300 { lab=#net4}
N 375 285 375 295 { lab=VN}
N 295 295 375 295 { lab=VN}
N 295 285 295 295 { lab=VN}
N 220 295 295 295 { lab=VN}
N 220 285 220 295 { lab=VN}
N 135 295 220 295 { lab=VN}
N 135 285 135 295 { lab=VN}
N 435 300 445 300 { lab=#net4}
N 405 250 480 250 { lab=Vbn}
N 435 -0 440 -0 { lab=Vbn}
N 520 0 520 90 { lab=#net5}
N 460 -25 460 -0 { lab=VP}
N 450 90 460 90 { lab=#net3}
N 450 90 450 175 { lab=#net3}
N 480 250 560 250 { lab=Vbn}
N -50 0 -35 0 { lab=VP}
N -50 0 -50 35 { lab=VP}
N -50 35 -40 35 { lab=VP}
N -40 35 -5 35 { lab=VP}
N -5 30 -5 35 { lab=VP}
N -50 -30 -50 0 { lab=VP}
N -75 45 35 45 { lab=Vb}
N -50 60 -5 60 { lab=VP}
N -50 90 -35 90 { lab=VP}
N -50 60 -50 90 { lab=VP}
N 25 90 50 90 { lab=#net2}
N 25 190 50 190 { lab=#net2}
N -5 220 -5 230 { lab=VN}
N -40 230 -5 230 { lab=VN}
N -50 230 -40 230 { lab=VN}
N -50 190 -50 230 { lab=VN}
N -50 190 -35 190 { lab=VN}
N -65 230 -50 230 { lab=VN}
N 0 255 -0 265 { lab=VN}
N -50 255 -0 255 { lab=VN}
N -50 255 -50 295 { lab=VN}
N -50 295 -30 295 { lab=VN}
N 85 255 85 265 { lab=VN}
N 50 255 85 255 { lab=VN}
N 50 255 50 295 { lab=VN}
N 50 295 55 295 { lab=VN}
N 30 295 30 300 { lab=VN}
N 30 300 115 300 { lab=VN}
N 115 295 115 300 { lab=VN}
N -0 255 50 255 { lab=VN}
N 450 190 460 190 { lab=#net4}
N 445 300 450 300 { lab=#net4}
N 460 285 460 300 { lab=#net4}
N 450 300 460 300 { lab=#net4}
N 490 255 520 255 { lab=VN}
N 520 255 520 285 { lab=VN}
N 530 285 530 300 { lab=#net4}
N 460 300 530 300 { lab=#net4}
N 560 255 590 255 { lab=VN}
N 590 255 590 285 { lab=VN}
N 560 250 605 250 { lab=Vbn}
N 560 30 590 30 { lab=VP}
N 590 0 590 30 { lab=VP}
N 590 -10 590 -0 { lab=VP}
N 520 -0 530 -0 { lab=#net5}
N 560 60 585 60 { lab=VP}
N 585 60 590 60 { lab=VP}
N 590 60 590 90 { lab=VP}
N -50 -100 585 -100 { lab=VP}
N 590 -100 590 -10 { lab=VP}
N 585 -100 590 -100 { lab=VP}
N 460 -100 460 -25 { lab=VP}
N 370 -100 370 -35 { lab=VP}
N 50 -100 50 -35 { lab=VP}
N -50 -100 -50 -30 { lab=VP}
N -80 -100 -50 -100 { lab=VP}
N -65 230 -65 255 { lab=VN}
N -65 255 -65 385 { lab=VN}
N 365 200 365 385 { lab=VN}
N 355 190 360 190 { lab=VN}
N 360 190 360 385 { lab=VN}
N 590 30 590 60 { lab=VP}
N -65 385 365 385 { lab=VN}
N 135 295 135 385 { lab=VN}
N 115 -100 115 70 { lab=VP}
N 125 -100 125 70 { lab=VP}
N -45 -100 -45 60 { lab=VP}
N -50 295 -50 385 { lab=VN}
N 590 285 590 380 { lab=VN}
N 365 385 590 385 { lab=VN}
N 590 380 590 385 { lab=VN}
N 520 285 520 385 { lab=VN}
N 490 220 605 220 { lab=Vcp}
N -5 -15 -5 0 { lab=VP}
N -50 -15 -5 -15 { lab=VP}
N -5 90 -5 95 { lab=VP}
N -50 95 -5 95 { lab=VP}
N -50 90 -50 95 { lab=VP}
N -5 180 -5 190 { lab=VN}
N -50 180 -5 180 { lab=VN}
N -50 180 -50 190 { lab=VN}
N 560 -15 560 0 { lab=VP}
N 560 -15 590 -15 { lab=VP}
N 560 90 560 95 { lab=VP}
N 560 95 590 95 { lab=VP}
N 590 90 590 95 { lab=VP}
N 560 285 560 300 { lab=VN}
N 560 300 585 300 { lab=VN}
N 585 300 590 300 { lab=VN}
N 520 180 535 180 { lab=#net5}
N 565 210 590 210 { lab=VN}
N 590 210 595 210 { lab=VN}
N 595 180 595 210 { lab=VN}
N 595 170 595 180 { lab=VN}
N 565 170 595 170 { lab=VN}
N 565 170 565 180 { lab=VN}
N 595 210 595 385 { lab=VN}
N 590 385 595 385 { lab=VN}
N 0 295 -0 300 { lab=VN}
N -50 300 -0 300 { lab=VN}
N 490 30 490 60 { lab=#net3}
N 450 190 450 300 { lab=#net4}
N 280 235 605 235 { lab=Vcn}
N 375 90 375 130 { lab=VP}
N 530 90 530 100 { lab=#net3}
N 450 100 530 100 { lab=#net3}
N 115 300 135 300 { lab=VN}
N 50 235 80 235 { lab=#net2}
N 50 190 50 235 { lab=#net2}
N 205 190 205 385 { lab=VN}
N 490 285 520 285 { lab=VN}
N 50 295 85 295 { lab=VN}
N 450 55 490 55 { lab=#net3}
N 450 55 450 90 { lab=#net3}
N 520 180 520 190 { lab=#net5}
N 520 105 520 180 { lab=#net5}
N 520 105 525 105 { lab=#net5}
N 525 55 525 105 { lab=#net5}
N 520 55 525 55 { lab=#net5}
N 80 30 165 30 { lab=Vb}
N 165 30 245 30 { lab=Vb}
N 245 30 325 30 { lab=Vb}
N 325 30 355 30 { lab=Vb}
N 355 0 355 30 { lab=Vb}
N 355 -10 355 0 { lab=Vb}
N 275 -10 355 -10 { lab=Vb}
N 275 -10 275 -0 { lab=Vb}
N 195 -10 275 -10 { lab=Vb}
N 195 -10 195 0 { lab=Vb}
N 110 -10 195 -10 { lab=Vb}
N 110 -10 110 0 { lab=Vb}
N 80 60 165 60 { lab=Vb}
N 165 60 245 60 { lab=Vb}
N 245 60 325 60 { lab=Vb}
N 325 60 405 60 { lab=Vb}
N 405 30 405 60 { lab=Vb}
N 355 30 405 30 { lab=Vb}
N 80 30 80 60 { lab=Vb}
N 35 -10 35 45 { lab=Vb}
N 35 -10 110 -10 { lab=Vb}
N 405 45 610 45 { lab=Vbp}
N 25 -10 25 -0 { lab=Vb}
N 25 -10 35 -10 { lab=Vb}
C {madvlsi/pmos3.sym} 80 0 3 0 {name=M1
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 325 190 3 0 {name=M2
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 165 0 3 0 {name=M3
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 245 0 3 0 {name=M4
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 325 0 3 0 {name=M5
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 165 90 3 1 {name=M6
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 245 90 3 1 {name=M7
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 325 90 3 1 {name=M8
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 405 90 3 1 {name=M9
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 80 90 1 0 {name=M10
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 80 190 3 0 {name=M11
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 165 190 3 0 {name=M12
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 190 3 0 {name=M13
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 405 190 3 0 {name=M14
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 405 0 3 0 {name=M15
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 325 285 1 0 {name=M16
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 405 285 1 0 {name=M17
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 250 285 1 0 {name=M18
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos3.sym} 165 285 1 0 {name=M19
L=0.5
W=12
body=GND
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 490 0 3 0 {name=M20
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 490 90 1 0 {name=M21
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos3.sym} 490 190 1 1 {name=M22
L=0.5
W=12
body=VDD
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {devices/iopin.sym} -80 -100 2 0 {name=p2 lab=VP}
C {devices/iopin.sym} -65 385 2 0 {name=p3 lab=VN}
C {devices/opin.sym} 605 235 0 0 {name=p5 lab=Vcn}
C {devices/opin.sym} 605 220 0 0 {name=p6 lab=Vcp}
C {devices/opin.sym} 605 250 0 0 {name=p7 lab=Vbn}
C {madvlsi/nmos4.sym} 0 295 1 0 {name=M23
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} -5 190 1 1 {name=M24
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 560 285 3 1 {name=M25
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} -5 90 1 0 {name=M27
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} -5 0 3 0 {name=M29
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 560 0 3 0 {name=M30
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/pmos4.sym} 560 90 3 1 {name=M31
L=0.5
W=12
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 565 180 3 0 {name=M32
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/ipin.sym} -75 45 0 0 {name=p1 lab=Vb}
C {madvlsi/nmos4.sym} 490 285 3 1 {name=M28
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {madvlsi/nmos4.sym} 85 295 1 0 {name=M26
L=0.5
W=12
nf=1 
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_01v8
spiceprefix=X
}
C {devices/opin.sym} 610 45 0 0 {name=p4 lab=Vbp}
